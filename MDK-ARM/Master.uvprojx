# Keil uVision project Master.uvprojx, settings and files
target Master (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Master +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx USE_STM32F4_DISCO,STM32F407xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../common;../cyclone_tcp;../cyclone_crypto;../cyclone_ssl;../ssd1306
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: GeneralFunction.c WeatherSensor.c ssd1306.c ssd1306_fonts.c ssd1306_tests.c xBee.c main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group CycloneTCP_common
    ../common/: cpu_endian.c date_time.c debug.c str.c os_port_freertos.c
  group CycloneTCP_
    ../cyclone_tcp/core/: bsd_socket.c bsd_socket_misc.c ethernet.c ethernet_misc.c ip.c net.c net_mem.c net_misc.c nic.c ping.c raw_socket.c socket.c socket_misc.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c
    ../cyclone_tcp/ipv4/: arp.c auto_ip.c auto_ip_misc.c icmp.c ipv4.c ipv4_frag.c ipv4_misc.c
    ../cyclone_tcp/drivers/phy/: lan8742_driver.c
    ../cyclone_tcp/drivers/mac/: stm32f4xx_eth_driver.c
    ../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c dhcp_server.c dhcp_server_misc.c
    ../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../cyclone_tcp/igmp/: igmp_common.c igmp_host.c igmp_host_misc.c igmp_router.c igmp_router_misc.c igmp_snooping.c igmp_snooping_misc.c
    ../cyclone_tcp/netbios/: nbns_client.c nbns_common.c nbns_responder.c
    ../cyclone_tcp/llmnr/: llmnr_client.c llmnr_common.c llmnr_responder.c
    ../cyclone_tcp/web_socket/: web_socket.c web_socket_auth.c web_socket_frame.c web_socket_misc.c web_socket_transport.c
  group CycloneTCP_crypto
    ../cyclone_crypto/rng/: yarrow.c
    ../cyclone_crypto/hardware/stm32f4xx/: stm32f4xx_crypto_trng.c stm32f4xx_crypto.c
    ../cyclone_crypto/aead/: ccm.c gcm.c chacha20_poly1305.c
    ../cyclone_crypto/cipher/: aes.c aria.c camellia.c chacha.c des.c des3.c idea.c rc4.c seed.c
    ../cyclone_crypto/cipher_mode/: cbc.c
    ../cyclone_crypto/ecc/: x448.c ed448.c ed25519.c x25519.c eddsa.c ecdsa.c ecdh.c ec_curves.c ec.c curve25519.c curve448.c
    ../cyclone_crypto/encoding/: asn1.c base64.c oid.c
    ../cyclone_crypto/hash/: sha1.c sha224.c sha256.c sha384.c sha512.c md5.c
    ../cyclone_crypto/kdf/: hkdf.c
    ../cyclone_crypto/mac/: hmac.c poly1305.c
    ../cyclone_crypto/mpi/: mpi.c
    ../cyclone_crypto/pkc/: dsa.c dh.c rsa.c
    ../cyclone_crypto/pkix/: pkcs8_key_parse.c x509_key_parse.c x509_cert_parse.c x509_cert_validate.c x509_crl_parse.c x509_crl_validate.c x509_common.c x509_signature.c pem_import.c
  group CycloneTCP_SSL
    ../cyclone_ssl/: tls13_misc.c tls13_ticket.c tls13_key_material.c tls13_signature.c tls13_common.c tls13_server_misc.c tls13_server_extensions.c tls13_client.c tls_misc.c tls_record_decryption.c tls_record_encryption.c tls_record.c tls_ffdhe.c tls_ticket.c tls_cache.c tls_transcript_hash.c tls_signature.c tls13_server.c tls13_client_misc.c tls13_client_extensions.c tls_server_misc.c tls_server_fsm.c tls_server_extensions.c tls_server.c tls_key_material.c tls_handshake.c tls_extensions.c tls_common.c tls_client_misc.c tls_client_fsm.c tls_client_extensions.c tls_client.c tls_cipher_suites.c tls_certificate.c tls.c dtls_record.c dtls_misc.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
